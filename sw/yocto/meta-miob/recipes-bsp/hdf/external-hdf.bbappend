EXTRAPATHS_prepend := "${THISDIR}/files:"
 
#Hardware Platform
HDF_BASE_miob-zcu106-zynqmp = "file://"
HDF_PATH_miob-zcu106-zynqmp = "220831_zcu106_smmu.xsa"
