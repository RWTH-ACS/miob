# as per https://lore.kernel.org/all/20220309194127.725972-1-jpuhlman@mvista.com/T/
EXTRA_OEMAKE_append_class-native = " EXTRA_LIBS='-lpthread -lrt -ldl'"
