FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://hostname.cfg \
     	    file://smmu.cfg \
            file://k3s.cfg"
